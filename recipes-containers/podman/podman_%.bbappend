# Enable rootless container support.
PACKAGECONFIG:append = " rootless"
