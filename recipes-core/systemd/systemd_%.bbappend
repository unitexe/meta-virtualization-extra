PACKAGECONFIG:append = " pam"
